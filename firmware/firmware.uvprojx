# Keil uVision project firmware.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F030K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Cosmos +hex
  c flags: Optim=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c define: STM32F030x6
  c include: src\include;src\core;src\core\include;src\core\hal\include;src\;src\app;src\sys;src\sys\hardware;src\ui;src\third\cortexm-AES
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group MAIN
    src/: boot.c
  group CORE
    src/core/hal/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_usart_ex.c stm32f0xx_hal_wwdg.c stm32f0xx_ll_adc.c stm32f0xx_ll_comp.c stm32f0xx_ll_crc.c stm32f0xx_ll_crs.c stm32f0xx_ll_dac.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_i2c.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_rtc.c stm32f0xx_ll_spi.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c stm32f0xx_ll_usb.c stm32f0xx_ll_utils.c
    src/core/: stm32f0xx_it.c
  group SYS
    src/sys/: button.c panic.c scheduler.c
    ./src/sys/: display.c
  group SYS/HARDWARE
    src/sys/hardware/: ch9329.c
    ./src/sys/hardware/: w25qx.c ch1115.c
  group APP
    src/app/: app.c
  group APP/LAYOUT
    src/app/layout/main/: unlock.c
  group UI/WIDGETS
    ./src/ui/widgets/: stack.c menu.c
  group SYS/CRYPTO
    ./src/sys/crypto/: aes.c
    ./src/third/cortexm-AES/aes/target/CM0_sBOX/: CM0_sBOX_AES_128_keyschedule_enc.S CM0_sBOX_AES_192_keyschedule_enc.S CM0_sBOX_AES_256_keyschedule_enc.S CM0_sBOX_AES_decrypt.S CM0_sBOX_AES_encrypt.S
    ./src/third/cortexm-AES/aes/target/: lookup_tables.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
